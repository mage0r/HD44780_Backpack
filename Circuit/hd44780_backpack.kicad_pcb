# Repository mage0r/HD44780_Backpack

File README.md:

Attiny 84 LCD Display for the HD44780
=============

This project uses an Attiny 84 to drive LCD Displays that use the HD44780 driver.  It's simple, small and compatible with a range of sizes.  The board can easily be trimmed down to the standard 16x2 size or left at it's original size for 20x4.

This version includes a large prototyping area and a mounting for a "mesthingy" from http://www.m9design.co/

There are three sections, the circuit design for kicad, some i2c arduino sketches and a few photos of the finished product.

This version is compatible with Marc Merlin's NewLiquidCrystal library (https://github.com/marcmerlin)

CREDITS
------------
This project was designed by John Spencer - john.spencer.9000@gmail.com - https://github.com/mage0r

SPECIAL THANKS
------------

To the HackMelbourne (CCHS, http://hackmelbourne.org) community of Melbourne, Australia.

To all other open-source developers whose countless hours supported every other aspect of this design.

DISTRIBUTION
------------
The specific terms of distribution of this project are governed by the
license referenced below. Please contact the copyright owner if you wish to modify the board for distribution. Please utilize this design for personal or research projects. Please acknowledge all contributors.

LICENSE
-------
Licensed under the TAPR Open Hardware License (www.tapr.org/OHL).
The "license" sub-folder also contains a copy of this license in plain text format.

Copyright John Spencer 2014
john.spencer.9000@gmail.com

## KiCad design Circuit/hd44780_backpack.kicad_pcb

Parts:
10k1: POT
C1: 0.1uf
C2: 10uf
IC1: ATTINY84A-SS; SO14
K1: PWR_SHIFT
M1: MESHTHING; MeshThing
P1: I2C
P2: ISCP
P3: ATTINY_BREAKOUT
P4: USB_5PIN_SHELL
P5: MESH_BKOUT_1-10
P6: MESH_BKOUT_11-20
P7: MESH_ENABLE
P8: ATTINY_ENABLE
P9: CONN_2
Q1: NPN
Q2: BSS138DW; SOT-23
R1: 1k
R2: 220
R3: 10k
R4, R5, R6, R7: 10K
R8: 1K
R9: 2K
SW1: Reset
U1: 74HC595-16-PIN
U2: HD44780

Connections:
+3.3V: K1.3, M1.1 (+3.3v), P5.10, Q2.2 (G), Q2.5 (G), R5.1, R7.2, R8.2, R9.1
+5V: 10k1.3, C1.1, C2.1, IC1.1 (VCC), K1.1, P2.2 (VCC), P4.1 (VCC), P9.1, R4.1, R6.2, R8.1, U2.2 (VCC), U2.15 (LED+)
GND: 10k1.1, C1.2, C2.2, IC1.14 (GND), M1.10 (GND), P2.6 (GND), P4.5 (GND), P5.1, P9.2 (PM), Q1.1 (E), R9.2, SW1.1, U1.8, U1.13, U2.1 (GND), U2.5 (R/!W)
unnamed: U1.4, U2.14 (D7)
unnamed: IC1.11 ((PCINT2/AIN1/ADC2)PA2), P8.7
unnamed: R2.1, U2.16 (LED-)
unnamed: P8.2, R1.1
unnamed: Q1.3 (C), R2.2
unnamed: Q1.2 (B), R1.2
unnamed: U1.3, U2.6 (E)
unnamed: U1.1, U2.4 (RS)
unnamed: U1.5, U2.13 (D6)
unnamed: U1.6, U2.12 (D5)
unnamed: U1.7, U2.11 (D4)
unnamed: M1.15 (PF5(D5/A5/2/-/-/-)), P6.6
unnamed: M1.14 (PE5(D15/-/39/-/INT5/OC3C)), P6.7
unnamed: M1.11 (PE4(D4/-/38/-/INT4/OC3B)), P6.10, P7.4
unnamed: M1.12 (PF7(D7/A7/47/-/-/-)), P6.9
unnamed: P8.4, U1.12
unnamed: IC1.5 ((PCINT10/CKOUT/OC0A/INT0)PB2), P3.4 (8)
unnamed: IC1.6 ((PCINT7/ICP/OC0B/ADC7)PA7), P3.3 (A7)
unnamed: IC1.12 ((PCINT1/AIN0/ADC1)PA1), P3.2 (A1)
unnamed: IC1.8 ((PCINT5/DO/MISO/OC1B/ADC5)PA5), P2.1 (MISO)
unnamed: K1.2 (PM), R3.2, U1.10, U1.16
unnamed: IC1.13 ((PCINT0/AREF/ADC0)PA0), P3.1 (A0)
unnamed: IC1.4 ((PCINT11/dW/~RESET~)PB3), P2.5 (RST), R3.1, SW1.2
unnamed: 10k1.2, U2.3 (Contrast)
unnamed: P8.6, U1.11
unnamed: P8.8, U1.14
unnamed: IC1.2 ((PCINT8/CLKI/XTAL1)PB0), P8.1
unnamed: IC1.3 ((PCINT9/XTAL2)PB1), P8.3
unnamed: IC1.10 ((PCINT3/T0/ADC3)PA3), P8.5
unnamed: M1.19 (PF1(D1/A1/47/-/-/-)), P6.2, P7.2
unnamed: M1.20 (PF0(D0/A0/46/-/-/-)), P6.1, P7.1
unnamed: M1.18 (PF2(D2/A2/48/-/-/-)), P6.3, P7.3
unnamed: M1.16 (PF6(D6/A6/3/-/-/-)), P6.5
unnamed: M1.5 (RESET(-/-/10/-/-)), P5.6
unnamed: M1.17 (PF3(D3/A3/1/-/-/-)), P6.4
unnamed: M1.2 (PE1(D18/-/35/TX0/-/-)), P5.9
unnamed: M1.3 (PE0(D19/-/34/RX0/PCINT8/-)), P5.8
unnamed: M1.4 (PD3(D8/-/20/TX1/INT3/-)), P5.7
unnamed: M1.6 (PB5(D10/-/31/RSSI/PCINT5/OC1A)), P5.5
unnamed: M1.7 (PB4(D14/-/30/-/PCINT4/OC2A)), P5.4
unnamed: M1.8 (PD2(D20/-/19/RX1/INT2/-)), P5.3
unnamed: IC1.7 ((PCINT6/SDA/DI/MOSI/OC1A/ADC6)PA6), P1.1 (SDA), P2.4 (MOSI), Q2.6 (D), R6.1
unnamed: M1.13 (PD0(D16/-/17/SCL/INT0/-)), P6.8, Q2.1 (S), R7.1
unnamed: IC1.9 ((PCINT4/USCK/SCL/T1/ADC4)PA4), P1.2 (SCL), P2.3 (SCK), Q2.3 (D), R4.2
unnamed: M1.9 (PD1(D9/-/18/SDA/INT1/-)), P5.2, Q2.4 (S), R5.2

Board: 2 copper layers, 98.4 x 60.3 mm, 31 parts (0 on the bottom side), 48 nets.

Other parts of the board:
PROTO_6X11: Z2; PROTO_6x11
PROTO_6X11_2: Z1; PROTO_6x11

## Commit log

2014-05-25 initial commit
    I've already lost hardware changes once already...
2014-05-25 not sure why this wasn't included before
2014-06-01 Modified Library
    Modified library included to handle a different pin output on the Shift
    Register than the default library expects.
2014-06-01 Example sketch replaced
    The replacement sketch now has the correct arduino pin-outs and the
    other non-relevant examples have been removed.
2014-06-01 Added license
2014-06-01 Added github link to text on back of board
2014-06-01 Photos and Readme added
2014-06-01 Updated readme text
2014-06-01 Bugs in version 1.0
2014-06-01 Attempted library for this hardware version
2014-06-01 Added additional photo
2014-06-02 non-working circuit.
2014-06-02 Meshthing integration complete
2014-06-02 missed a few files
2014-06-04 Changed to using a BSS138DW
2014-06-05 Bluetooth sketch and photos
2014-06-07 Added links to components
    and prices to build a bom.
2014-06-21 Removed un-needed libraries.
    this version is compatible with the basic newLiquidCrystal library
2014-06-21 weirdness.
2014-06-21 wrong link
2014-06-23 problem with back masks
    the meshthingy had no back mask area. made it very difficult to solder.
2014-07-02 test i2c code.
    Simple send text
2014-07-05 working i2c master and slave
    Can now do a bunch of operations using the i2c bus
2014-07-05 updated mesthing module
    back mask was missing
2014-07-05 added photos
2014-07-05 updated readme, again
2014-07-06 Added Schematic pdf
    For easy viewing.
2014-07-06 Added basic RequestFrom and Send support
    They're working, but are definitely still in testing.
    No other functionality is affected.
2014-11-04 improvements to i2c communications
2014-11-15 Updated image links
